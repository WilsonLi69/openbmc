FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-hwmontemp-Add-support-for-LM95241.patch"

