FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ARM-dts-ast2500-Update-model-name-for-custom-board.patch"
SRC_URI += "file://defconfig.cfg"

